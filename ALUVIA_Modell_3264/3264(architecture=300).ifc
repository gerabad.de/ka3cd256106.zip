Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_581/temp/tmp_3556_133_Ioluv/format_1/3264(architecture=300).ifc
Time: 2025-09-01T09:05:09
Made in: PARTsolutions

# IfcProject, 3264(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3264(architecture=300)
In: BUILDING
Description: 3264(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3264
ePset_PARTsolutions - NB: 3264(architecture=300); NN: 3264; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3264(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3264; B: 3264_aluvia_900x1400.png; C: ALUVIA; E: KALDEWEI; EF000049: 900; EF004567: 1400; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1400; etim7_EC003246_LENGTH: 900
